# Keil uVision project iSO-STM32.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: APP +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ../bin/APP.bin ../../Output/APP.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Ethernet\Internet;..\..\User\Ethernet\W5500;..\..\User\usart;..\..\sensor\led;..\..\User\I2C_EEPROM;..\..\User\spi;..\..\User\bsp_dht11;..\..\User\TimBase;..\..\User\i2c;..\..\sensor\Team&Huy;..\..\sensor\BT;..\..\User\iwdg;..\..\sensor\TSL2561;..\..\User\OTA;..\..\sensor\Flash;..\..\User\BT;..\..\User\Key;..\..\User\adc;..\..\User\esp8266;..\..\sensor\CO2;..\..\sensor\CO;..\..\sensor\BQ24259;..\..\sensor\PM2.5
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_adc.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/spi/: bsp_spi_flash.c bsp_spi_flash.h
    ../../User/TimBase/: bsp_TiMbase.c bsp_TiMbase.h
    ../../User/i2c/: bsp_i2c_ee.c
    ../../User/iwdg/: bsp_iwdg.c
    ../../User/OTA/: IAP_Bootload.c
    ../../User/usart/: bsp_usart.c
    ../../User/BT/: BT.c
    ../../User/adc/: bsp_adc.c
    ../../User/esp8266/: esp8266.c
    ../../User/Key/: bsp_key.c
  group W5500
    ../../User/Ethernet/W5500/: w5500_conf.c w5500_conf.h w5500.c w5500.h socket.c socket.h utility.c utility.h types.h
  group Internet
    ../../User/Ethernet/Internet/: tcp_demo.c tcp_demo.h dhcp.c dhcp.h
  group sensor
    ../../sensor/Flash/: flash.c
    ../../sensor/BQ24259/: BQ24259.c
    ../../sensor/CO/: CO.c
    ../../sensor/CO2/: CO2.c
    ../../sensor/led/: bsp_led.c
    ../../sensor/PM2.5/: PM25.c
    ../../sensor/Team&Huy/: Team_Huy.c
    ../../sensor/TSL2561/: TSL2561.c
