# Keil uVision project hermes_project_2018.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APP +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ../bin/APP.bin ../USER/APP.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;.\PM2.5\usart2;.\RTLWIFI\Common;.\RTLWIFI\SysTick;.\RTLWIFI\ESP8266;..\SENSOR\led;.\Key;.\adc;.\wifi_ep8266;..\SENSOR\PM2.5;..\SENSOR\TSL2561;..\SENSOR\CO2;..\SENSOR\Team&Huy;.\RTL&WIFI;..\SENSOR\CO;.\iwdg;..\SENSOR\BQ24259;..\SENSOR\Flash;.\OTA;.\BT
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ./i2c/: bsp_i2c_ee.c
    ./usart/: bsp_usart.c
    ./RTLWIFI/Common/: Common.c
    ./RTLWIFI/SysTick/: bsp_SysTick.c
    ./Key/: bsp_key.c
    ./adc/: bsp_adc.c
    ./RTL&WIFI/: bsp_RTL_WIFI.c
    ./OTA/: IAP_Bootload.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ./iwdg/: bsp_iwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SENSOR
    ../SENSOR/BQ24259/: BQ24259.c
    ../SENSOR/CO/: CO.c
    ../SENSOR/CO2/: CO2.c
    ../SENSOR/led/: bsp_led.c
    ../SENSOR/PM2.5/: PM25.c
    ../SENSOR/Team&Huy/: Team_Huy.c
    ../SENSOR/TSL2561/: TSL2561.c
    ../SENSOR/Flash/: spi_flash.c
    ./BT/: BT.c
  group README
    ../: README.TXT
