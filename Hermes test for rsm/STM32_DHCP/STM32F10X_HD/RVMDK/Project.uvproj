# Keil uVision project Project.uvproj, settings and files
target STM32F10X_HD (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: APP +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ../bin/APP.bin ../Output/APP.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\;..\Src;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Src\modbus\include;..\Src\modbus\port;..\Src\modbus\rtu;..\Src\modbus\ascii;..\Src\sensor\TSL2561;..\Src\basic\i2c;..\Src\basic\usart;..\Src\sensor\temp_humi;..\FreeRTOS\include;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\include;..\SYSTEM\delay;..\Src;..\Src\sensor\PM2.5;..\Src\sensor\adc;..\Src\sensor\Ethernet\W5500;..\Src\sensor\Ethernet\Internet;..\Src\sensor\spi;..\Src\sensor\TimBase;..\Src\sensor\Ethernet\W5500;..\Src\sensor\Ethernet\W5500;..\SYSTEM\iwdg;..\Src\sensor\Ethernet\Internet;..\Src\sensor\BT;..\Src\sensor\led;..\SYSTEM\Flash;..\SYSTEM\OTA;..\SYSTEM\Key;..\Src\param_config
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../Src/Wizard_STM32_Init/: STM32_Init.c
    ../Src/: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group DeviceSupport
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Modbus
    ../Src/modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Src/modbus/rtu/: mbcrc.c mbrtu.c
    ../Src/modbus/: mb.c
    ../Src/modbus/ascii/: mbascii.c
    ../Src/modbus/tcp/: mbtcp.c
  group port
    ../Src/modbus/port/: portevent.c portserial.c porttimer.c port.c
  group sensor
    ../Src/sensor/TSL2561/: TSL2561.c
    ../Src/sensor/temp_humi/: temp_humi.c
    ../Src/sensor/PM2.5/: PM25.c
    ../Src/sensor/adc/: bsp_adc.c
    ../Src/sensor/Ethernet/Internet/: dhcp.c tcp_demo.c
    ../Src/sensor/Ethernet/W5500/: socket.c w5500.c w5500_conf.c
    ../Src/sensor/spi/: bsp_spi_flash.c
    ../Src/sensor/TimBase/: bsp_TiMbase.c
    ../Src/sensor/BT/: BT.c
    ../Src/sensor/led/: bsp_led.c
  group basic
    ../Src/basic/usart/: bsp_usart1.c
    ../Src/basic/i2c/: bsp_i2c_ee.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/iwdg/: bsp_iwdg.c
    ../SYSTEM/Key/: bsp_key.c
    ../SYSTEM/Flash/: flash.c
    ../SYSTEM/OTA/: IAP_Bootload.c
    ../Src/param_config/: param_config.c
  group user_task
    ../Src/: user_task.c
  group Doc
    ./: KeilConfig.txt
